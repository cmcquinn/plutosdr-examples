options:
  parameters:
    author: cameron
    generate_options: qt_gui
    id: atsc_raw
    output_language: python
    title: ATSC Waterfall and FFT
  states: {}

blocks:
- name: atsc_bw
  id: variable
  parameters:
    value: int(6e6)
  states: {}
- name: channel
  id: variable_qtgui_range
  parameters:
    label: Channel Number
    orient: Qt.Horizontal
    rangeType: int
    start: '14'
    step: '1'
    stop: '51'
    value: '32'
    widget: counter
  states: {}
- name: fc
  id: variable
  parameters:
    value: (6*channel + 389)*1000000
  states: {}
- name: output_rate
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: oversamp_rate
  id: variable
  parameters:
    value: '1.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 4.5e6/286*684
  states: {}
- name: dtv_atsc_rx_filter_0
  id: dtv_atsc_rx_filter
  parameters:
    rate: samp_rate
    sps: oversamp_rate
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'False'
    bandwidth: atsc_bw
    bbdc: 'True'
    buffer_size: '32768'
    frequency: fc
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: atsc_bw
    fc: fc
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [dtv_atsc_rx_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [dtv_atsc_rx_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [iio_pluto_source_0, '0', dtv_atsc_rx_filter_0, '0']

metadata:
  file_format: 1
