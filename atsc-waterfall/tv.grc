options:
  parameters:
    generate_options: qt_gui
    id: tv
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: atsc_bw
  id: variable
  parameters:
    value: int(6e6)
  states: {}
- name: channel
  id: variable_qtgui_range
  parameters:
    label: Channel Number
    orient: Qt.Horizontal
    rangeType: int
    start: '14'
    step: '1'
    stop: '51'
    value: '32'
    widget: counter
  states: {}
- name: fc
  id: variable
  parameters:
    value: (6*channel + 389)*1000000
  states: {}
- name: output_rate
  id: variable
  parameters:
    value: samp_rate*symbol_rate
  states: {}
- name: oversamp_rate
  id: variable
  parameters:
    value: '1.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6.25e6
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 4.5e6/286*684
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-5'
    reference: '4.0'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out.mpeg
    type: byte
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '4096'
    long_form: 'True'
    type: ff
  states: {}
- name: dtv_atsc_deinterleaver_0
  id: dtv_atsc_deinterleaver
  parameters: {}
  states: {}
- name: dtv_atsc_depad_0
  id: dtv_atsc_depad
  parameters: {}
  states: {}
- name: dtv_atsc_derandomizer_0
  id: dtv_atsc_derandomizer
  parameters: {}
  states: {}
- name: dtv_atsc_equalizer_0
  id: dtv_atsc_equalizer
  parameters: {}
  states: {}
- name: dtv_atsc_fpll_0
  id: dtv_atsc_fpll
  parameters:
    rate: output_rate
  states: {}
- name: dtv_atsc_fs_checker_0
  id: dtv_atsc_fs_checker
  parameters: {}
  states: {}
- name: dtv_atsc_rs_decoder_0
  id: dtv_atsc_rs_decoder
  parameters: {}
  states: {}
- name: dtv_atsc_rx_filter_0
  id: dtv_atsc_rx_filter
  parameters:
    rate: samp_rate
    sps: oversamp_rate
  states: {}
- name: dtv_atsc_sync_0
  id: dtv_atsc_sync
  parameters:
    rate: output_rate
  states: {}
- name: dtv_atsc_viterbi_decoder_0
  id: dtv_atsc_viterbi_decoder
  parameters: {}
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'False'
    bandwidth: atsc_bw
    bbdc: 'True'
    buffer_size: '32768'
    frequency: fc
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: float(fc)
    fftsize: '1024'
    gui_hint: 0,0,1,2
    name: '"PlutoSDR"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: float(fc)
    fftsize: '1024'
    gui_hint: 1,0,1,2
    name: '"RX Filter"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,1
    name: '"FPLL"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '0.03'
    ymin: '-0.03'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,1,1,1
    name: '"DC Filter"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '0.03'
    ymin: '-0.03'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,2,1,1
    name: '"AGC"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '15'
    ymin: '-15'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: float(fc)
    fftsize: '1024'
    gui_hint: 0,2,1,2
    name: '"PlutoSDR"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: float(fc)
    fftsize: '1024'
    gui_hint: 1,2,1,2
    name: '"RX Filter"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_agc_xx_0, '0', dtv_atsc_sync_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_1_0, '0']
- [dc_blocker_xx_0, '0', analog_agc_xx_0, '0']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_1, '0']
- [dtv_atsc_deinterleaver_0, '0', dtv_atsc_rs_decoder_0, '0']
- [dtv_atsc_depad_0, '0', blocks_file_sink_0, '0']
- [dtv_atsc_derandomizer_0, '0', dtv_atsc_depad_0, '0']
- [dtv_atsc_equalizer_0, '0', dtv_atsc_viterbi_decoder_0, '0']
- [dtv_atsc_fpll_0, '0', dc_blocker_xx_0, '0']
- [dtv_atsc_fpll_0, '0', qtgui_time_sink_x_0, '0']
- [dtv_atsc_fs_checker_0, '0', dtv_atsc_equalizer_0, '0']
- [dtv_atsc_rs_decoder_0, '0', dtv_atsc_derandomizer_0, '0']
- [dtv_atsc_rx_filter_0, '0', dtv_atsc_fpll_0, '0']
- [dtv_atsc_rx_filter_0, '0', qtgui_freq_sink_x_0_1, '0']
- [dtv_atsc_rx_filter_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [dtv_atsc_sync_0, '0', dtv_atsc_fs_checker_0, '0']
- [dtv_atsc_viterbi_decoder_0, '0', dtv_atsc_deinterleaver_0, '0']
- [iio_pluto_source_0, '0', dtv_atsc_rx_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
